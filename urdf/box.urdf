Commit message: test exec for mpc

File: urdf/box.urdf (robot description, URDF)
Before this commit: robot car_box, 1 links, 0 joints
Links:
- removed link base_link
- added link mpc_base_link; visual box size=3 1.5 1
